# Keil uVision project Firmware.uvprojx, settings and files
target Firmware (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HID +hex
  c flags: Optim=4 OneElfS=1
  c define: HSE_VALUE=8000000
  c include: SSD1306;.\; RTE; RTE\Device\STM32F103C8
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./: Main.c USBD_User_HID_0.c AD9106.c AD9106.h AD9106_R.h ADT7516.c ADT7516.h ADT7516_R.h Leds.c Leds.h
  group SSD1306
    ./SSD1306/: fonts.c fonts.h SSD1306.c SSD1306.h SSD1306_I2C.c SSD1306_I2C.h
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, USB:CORE 6.5.0, USB:Device 6.5.0, USB:Device:HID 6.5.0, CMSIS Driver:USB Device 2.0, Device:DMA 1.2, Device:GPIO 1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0

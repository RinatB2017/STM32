<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Test_stm32l151rb.ewp</path>
  </project>
  <batchBuild />
</workspace>
